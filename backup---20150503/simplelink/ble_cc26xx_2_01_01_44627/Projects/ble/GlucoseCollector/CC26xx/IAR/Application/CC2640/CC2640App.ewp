# IAR project CC2640App.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; HEAPMGR_SIZE=3072; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs; -f ..\..\Config\IAR-Boundary.bdef
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/Glucose/CC26xx; ../../../../../../../Projects/ble/Profiles/Glucose; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; ../../../../../../../Projects/ble/common/cc26xx/Time; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GlucoseCollectorFlashROM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: GlucoseCollectorAppFlashROM.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\Config\IAR-Boundary.xcl
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROMDbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/Glucose/CC26xx; ../../../../../../../Projects/ble/Profiles/Glucose; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; ../../../../../../../Projects/ble/common/cc26xx/Time; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  OBJCOPY.OOCOutputFile: GlucoseCollectorSource.hex
  ILINK.IlinkOutputFile: GlucoseCollectorAppFlashROMDbg.out
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  group Application
    ../../../../../common/cc26xx/: board_key.c board_key.h board_lcd.c board_lcd.h util.c util.h
    ../../../Source/Application/: glucose_config.c glucose_ctlpnt.c glucose_discovery.c glucose_ind.c glucoseCollector.c glucoseCollector.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../../Components/applib/heap/: heapmgr.h
    ../../../../../../../Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../../../Components/icall/include/: ICall.h
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    ../../../../../ICall/Application/: bleUserConfig.c ICallBleAPI.c
    ../../../../../ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group PROFILES
    ../../../../../Profiles/Roles/CC26xx/: central.c central.h
    ../../../../../Profiles/DevInfo/CC26xx/: devinfoservice.c
    ../../../../../Profiles/DevInfo/: devinfoservice.h
    ../../../../../Include/: gatt_profile_uuid.h
    ../../../../../../../Components/ble/host/: gatt_uuid.c
    ../../../../../../../Components/ble/include/: gatt_uuid.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
    ../../../../../Profiles/Glucose/CC26xx/: glucservice.c
    ../../../../../Profiles/Glucose/: glucservice.h
  group Startup
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
  group TOOLS
    ../../Config/: appBLE.cfg IAR-Boundary.bdef IAR-Boundary.xcl
    ../../../../../common/cc26xx/IAR/: cc26xx_ble_app.icf
  group Include
    ../../../../../../../Components/ble/include/: gap.h gatt.h hci.h
    ../../../../../Include/: gapgattserver.h
    ../../../../../Profiles/Roles/: gapbondmgr.h
    ../../../../../../../Components/osal/include/: osal_snv.h
