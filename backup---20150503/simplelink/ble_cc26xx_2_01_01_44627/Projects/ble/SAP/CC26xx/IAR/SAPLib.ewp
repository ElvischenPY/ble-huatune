# IAR project SAPLib.ewp, settings and files
configuration SAPLib (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; POWER_SAVING
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi; -Dxdc_target_name__=M3; -Dxdc_target_types__=iar/targets/arm/std.h
  ICCARM.CCIncludePath2: ../Source; ../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../Components/hal/include; ../../../../../Components/osal/include; ../../../../../Components/ble/include; ../../../../../Components/npi/unified; ../../../../../Components/npi/unified/subsystem; ../../../Include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID; $XDCPATH$; $XDCROOT$/packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ApplicationProcessor.hex
  ILINK.IlinkOutputFile: ApplicationProcessor.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SAPLib_noPM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; xPOWER_SAVING
  group NPI
    ../../../../../Components/npi/unified/inc/: npi_data.h npi_task.h npi_util.h
    ../../../../../Components/npi/unified/: npi_task.c npi_util.c
  group NPI/Subsystem
    ../Source/: npi_ss_ble_sap.c npi_ss_ble_sap.h
  group NPI/TL
    ../../../../../Components/npi/unified/: npi_tl.c
    ../../../../../Components/npi/unified/inc/: npi_tl.h
  group NPI/TL/UART
    ../../../../../Components/npi/unified/inc/: npi_tl_uart.h
    ../../../../../Components/npi/unified/: npi_tl_uart_m.c
  group SAP
    ../Source/: sap.c sap.h snp_rpc.c snp_rpc.h snp_rpc_synchro.c snp_rpc_synchro.h
    ../../../Include/: SNP.h
