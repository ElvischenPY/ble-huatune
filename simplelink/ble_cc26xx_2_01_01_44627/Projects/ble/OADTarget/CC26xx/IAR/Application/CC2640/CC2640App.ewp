# IAR project CC2640App.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ICALL; ICALL_STACK0_ADDR=0xF000; POWER_SAVING; FEATURE_OAD; FEATURE_OAD_ONCHIP; HAL_IMAGE_A; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\..\..\..\..\..\..\Projects\ble\config\buildComponents.opt; -f configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/OAD/CC26xx; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/nv; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OADTargetApp.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  postbuild: python "C:\Python27\Scripts\hexmerge.py" -o "FlashROM\Exe\OAD_merge.hex" -r "0000:1FFFF" --overlap=error "FlashROM\Exe\OADTargetApp.hex":0100:1FFFF "..\..\..\..\..\util\BIM\CC26xx\FlashOnly\Exe\BIM.hex":0000:1F5FF "..\..\Stack\CC2640\FlashROM\Exe\OADTargetStackFlashROM.hex":F000:1EFFF
  ILINK.IlinkOutputFile: OADTargetApp.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROMDbg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_ICALL; POWER_SAVING; ICALL_STACK0_ADDR=0xF000; FEATURE_OAD; FEATURE_OAD_ONCHIP; HAL_IMAGE_A; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; ICALL_MAX_NUM_TASKS=3; ICALL_MAX_NUM_ENTITIES=6; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; CC26XXWARE; CC26XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/ICall/Include; ../../../../../../../Projects/ble/Profiles/Roles/CC26xx; ../../../../../../../Projects/ble/Profiles/Roles; ../../../../../../../Projects/ble/Profiles/OAD/CC26xx; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/Profiles/SimpleProfile/CC26xx; ../../../../../../../Projects/ble/Profiles/SimpleProfile; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/ble/controller/CC26xx/include; ../../../../../../../Components/ble/host; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/icall/include; ../../../../../../../Components/ble/include; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$\ti\boards\SRF06EB\CC2650EM_7ID
  OBJCOPY.OOCOutputFile: OADTargetFlashROMDbg.hex
  postbuild: python "C:\Python27\Scripts\hexmerge.py" -o "FlashROM\Exe\OAD_merge.hex" -r "0000:1FFFF" --overlap=error "FlashROMDbg\Exe\OADTargetFlashROMDbg.hex":0100:1FFFF "..\..\..\..\..\util\BIM\CC26xx\FlashOnly\Exe\BIM.hex":0000:1F5FF "..\..\Stack\CC2640\FlashROM\Exe\OADTargetStackFlashROM.hex":F000:1EFFF
  ILINK.IlinkOutputFile: OADTargetFlashROMDbg.out
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  group Application
    ../../../Source/Application/: oadTargetApp.c oadTargetApp.h
    ../../../../../common/cc26xx/: util.c util.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../../../Components/applib/heap/: heapmgr.h
    ../../../../../../../Components/icall/ports/tirtos/: ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../../../Components/icall/include/: ICall.h
    ../../../../../../../Components/hal/target/CC2650TIRTOS/: ICallAddrs.h
  group ICallBLE
    ../../../../../ICall/Application/: bleUserConfig.c ICallBleAPI.c
    ../../../../../ICall/Include/: bleUserConfig.h ICallBleAPIMSG.h
  group Include
    ../../../../../../../Components/ble/include/: gap.h gatt.h hci.h
    ../../../../../Profiles/Roles/: gapbondmgr.h
    ../../../../../Include/: gapgattserver.h
    ../../../../../../../Components/osal/include/: osal_snv.h
  group PROFILES
    ../../../../../Include/: gatt_profile_uuid.h
    ../../../../../../../Components/ble/host/: gatt_uuid.c
    ../../../../../../../Components/ble/include/: gatt_uuid.h
    ../../../../../Profiles/GATT/: gattservapp_util.c
    ../../../../../Profiles/OAD/CC26xx/: oad.c oad.h oad_target.h oad_target_internalFlash.c
    ../../../../../Profiles/Roles/CC26xx/: peripheral.c peripheral.h
  group Startup
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SRF06EB/: Board.c
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg
    ../../../../../common/cc26xx/IAR/: cc26xx_ble_app_oad.icf
