# IAR project CC2640App.ewp, settings and files
configuration CC2640EM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; POWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_DEFAULT_USER_CFG; CC26XXWARE; CC26XX
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../SAP/CC26xx/Source; ../../../../../../../Projects/ble/Profiles/SimpleProfile/SAP; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/ble/hci; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/ble/include; ../../../../../../../Components/npi/unified; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ../../../Source/Application/Board_EM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SimpleAPTesterEM.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SimpleAPTester.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26xxware.arm3; ..\..\..\..\..\SAP\CC26xx\IAR\SAPLib\Exe\SAPLib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CC2640EM-Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; xPOWER_SAVING; HEAPMGR_SIZE=2672; TI_DRIVERS_SPI_DMA_INCLUDED; TI_DRIVERS_LCD_INCLUDED; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_DEFAULT_USER_CFG; CC26XXWARE; CC26XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../SAP/CC26xx/Source; ../../../../../../../Projects/ble/Profiles/SimpleProfile/SAP; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/ble/include; ../../../../../../../Components/npi/unified; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; ../../../Source/Application/Board_EM
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
configuration CC2650STK (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; POWER_SAVING; FEATURE_OAD; HEAPMGR_SIZE=2672; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_SPI_INCLUDED; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_DEFAULT_USER_CFG; CC26XXWARE; CC26XX
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../Source/Application; ../../../../../SAP/CC26xx/Source; ../../../../../../../Projects/ble/Profiles/OAD/cc26xx; ../../../../../../../Projects/ble/Profiles/OAD/SAP; ../../../../../../../Projects/ble/Profiles/SimpleProfile/SAP; ../../../../../../../Projects/ble/Include; ../../../../../../../Projects/ble/Profiles/DevInfo; ../../../../../../../Projects/ble/common/cc26xx; ../../../../../../../Components/applib/heap; ../../../../../../../Components/hal/target/CC2650/rom; ../../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../../Components/hal/include; ../../../../../../../Components/osal/include; ../../../../../../../Components/services/sdata; ../../../../../../../Components/services/saddr; ../../../../../../../Components/ble/include; ../../../../../../../Components/npi/unified; ../../../../../../../Components/sbl/cc26xx; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/boards/sensortag/interfaces; $TI_RTOS_DRIVERS_BASE$/ti/boards/sensortag/devices; ../../../Source/Application/Board_STK
  OBJCOPY.OOCOutputFile: SimpleAPTesterST.hex
  ILINK.IlinkOutputFile: SimpleAPTesterST.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: ..\..\..\..\..\common\cc26xx\IAR\cc26xx_ble_app_oad.icf
configuration CC2650STK-Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  ICCARM.CCDefines: NPI_USE_UART; NPI_MASTER; xPOWER_SAVING; FEATURE_OAD; HEAPMGR_SIZE=2672; TI_DRIVERS_PIN_INCLUDED; TI_DRIVERS_SPI_INCLUDED; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_DEFAULT_USER_CFG; CC26XXWARE; CC26XX
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: SimpleAPTesterST.hex
  ILINK.IlinkOutputFile: SimpleAPTesterST.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=1; APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  group Application
    ../../../../../common/cc26xx/: board_key.c board_key.h board_lcd.c board_lcd.h util.c util.h
    ../../../Source/Application/: SimpleAP.c SimpleAP.h SimpleAP_STK.c
  group Board/Devices
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SensorTag/Devices/: ext_flash.c ext_flash.h
  group Board/Interfaces
    $TI_RTOS_DRIVERS_BASE$/ti/boards/SensorTag/Interfaces/: bsp_spi.c bsp_spi.h
  group Drivers/LCD
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/lcd/: LCDDogm1286.c LCDDogm1286.h LCDDogm1286_util.c LCDDogm1286_util.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/SPI
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: SPI.c SPI.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/spi/: SPICC26XXDMA.c SPICC26XXDMA.h
  group Drivers/UART
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: UART.c UART.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/uart/: UARTCC26XX.c UARTCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group NPI
    ../../../../../../../Components/npi/unified/inc/: npi_data.h npi_task.h npi_util.h
    ../../../../../../../Components/npi/unified/: npi_task.c npi_util.c
  group NPI/Subsystem
    ../../../../../SAP/CC26xx/Source/: npi_ss_ble_sap.c npi_ss_ble_sap.h
  group NPI/TL
    ../../../../../../../Components/npi/unified/: npi_tl.c
    ../../../../../../../Components/npi/unified/inc/: npi_tl.h
  group NPI/TL/UART
    ../../../../../../../Components/npi/unified/inc/: npi_tl_uart.h
    ../../../../../../../Components/npi/unified/: npi_tl_uart_m.c
  group PROFILES
    ../../../../../Profiles/OAD/SAP/: oad_sap.c oad_sap.h
    ../../../../../Profiles/OAD/CC26xx/: oad_target_externalFlash.c
    ../../../../../Profiles/SimpleProfile/SAP/: simpleGATTprofile.c simpleGATTProfile.h
  group SAPSource
    ../../../../../SAP/CC26xx/Source/: sap.c sap.h snp_rpc.c snp_rpc.h snp_rpc_synchro.c snp_rpc_synchro.h
    ../../../../../Include/: SNP.h
  group SBL
    ../../../../../../../Components/sbl/cc26xx/: sbl.c sbl.h sbl_cmd.c sbl_cmd.h sbl_image.h sbl_tl.c sbl_tl.h
    ../../../../../../../Components/sbl/cc26xx/image/: sbl_image_ext.c
  group Startup
    ../../../Source/Application/Board_EM/: Board.c
    ../../../Source/Application/Board_STK/: Board.c
    ../../Config/: ccfg_appBLE.c
    ../../../Source/Application/: main.c
  group TOOLS
    ../../Config/: appBLE.cfg
    ../../../../../common/cc26xx/IAR/: cc26xx_ble_app.icf cc26xx_ble_app_oad.icf
