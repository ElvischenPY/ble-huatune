# IAR project BIM.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Source; ../../../../Profiles/OAD/CC26xx; ../../../../../../Components/ble/include; ../../../../../../Components/osal/include; ../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../Components/hal/include; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BIM.hex
  ILINK.IlinkOutputFile: BIM.out
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1
  ILINK.IlinkIcfFile: ..\..\..\..\common\cc26xx\IAR\cc13xx_bim_dual_img.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Source/: bim_main.c ccfg_appBLE.c
  group TOOLS
    ../../../../common/cc26xx/IAR/: cc13xx_bim_dual_img.icf
