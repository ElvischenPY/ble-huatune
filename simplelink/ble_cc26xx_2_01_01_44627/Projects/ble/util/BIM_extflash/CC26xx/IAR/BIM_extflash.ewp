# IAR project BIM_extflash.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640F128 TexasInstruments CC2640F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; CC2650ST_0120; BOOT_LOADER; xNO_COPY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Source/CC26xx; ../Source/CC26XXST_0120; ../../../../Profiles/OAD/CC26xx; ../../../../../../Components/ble/include; ../../../../../../Components/osal/include; ../../../../../../Components/hal/target/CC2650TIRTOS; ../../../../../../Components/hal/target/_common/cc26xx; ../../../../../../Components/hal/include; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BIM_ext.hex
  ILINK.IlinkOutputFile: BIM_ext.out
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1; KEEP_INTVECS=1
  ILINK.IlinkIcfFile: ..\..\..\..\common\cc26xx\IAR\cc26xx_bim_extflash.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_SensorTag (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkConfigDefines: RTOS_IN_ROM=1; xKEEP_INTVECS=1
  group Application
    ../Source/: baseloaderentry_iar.s bim_main.c bls_bsp.c ccfg_appBLE.c
  group Ext Flash
    ../Source/CC26XXST_0120/: ext_flash.c ext_flash.h
  group SPI
    ../Source/CC26XXST_0120/: bsp_spi.c bsp_spi.h
  group TOOLS
    ../../../../common/cc26xx/IAR/: cc26xx_bim_extflash.icf
